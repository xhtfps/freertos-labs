# Keil uVision project atk_f407.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --no-multibyte-chars
  c include: .;User;Drivers;Drivers\BSP;Drivers\BSP\EXTI;Drivers\BSP\TIMER;Drivers\BSP\AD9959;Drivers\PGA112;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CMSIS\Include;Drivers\STM32F4xx_HAL_Driver\Inc;Middlewares;Middlewares\FreeRTOS\include;Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ./User/: main.c stm32f4xx_it.c freertos_demo.c User.c user_calibration.c user_history.c user_measure.c user_ui.c
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ./Drivers/SYSTEM/delay/: delay.c
    ./Drivers/SYSTEM/sys/: sys.c
    ./Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c
  group Drivers/BSP
    ./Drivers/BSP/LED/: led.c
    ./Drivers/BSP/KEY/: key.c
    ./Drivers/BSP/SRAM/: sram.c
    ./Drivers/BSP/TIMER/: btim.c ultrasonic_timer.c ultrasonic_timebase.c ultrasonic_pwm.c
    ./Drivers/BSP/PS2/: ps2.c
    ./Drivers/BSP/EXTI/: exti.c
    ./Drivers/PGA112/: PGA112.c SPI.c soft_spi_bus.c
    ./Drivers/BSP/AD9959/: AD9959.c
  group Middlewares/MALLOC
    ./Middlewares/MALLOC/: malloc.c
  group Middlewares/XMRAM
    ./Middlewares/XMRAM/: XMRAM.h XMRAM.lib
  group Middlewares/FreeRTOS_CORE
    ./Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Readme
    ./: readme.txt
  group Dreives/TFT_LCD
    ./Drivers/TFT_LCD/: Character.c fonts.c spi.c text.c fontupd.c TFT_LCD.c W25Q64.c
